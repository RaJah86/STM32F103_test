# Keil uVision project STM32F103_test.uvprojx, settings and files
target Target 1 (5060061::V5.06 update 1 (build 61)::ARMCC)
  device: STM32F103C8 STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.0.0
  cpu: IROM(0x08000000,0x10000) IRAM(0x20000000,0x5000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: STM32F103_test +hex
  c flags: Optim=1 OneElfS=1 wLevel=2
  c include: .\CMSIS;.\main_files
  asm include: .\CMSIS;.\main_files
  memory RVCT4: ROM 0x8000000 size 0x10000
  memory RVCT9: RAM 0x20000000 size 0x5000
  group MAIN
    ./: MAIN.c
    ./main_files/: SYS_Clock.c I2C.c OLED_Mono_128x64.c bb.h
  group CMSIS
    ./CMSIS/: startup_stm32f10x_md.s
